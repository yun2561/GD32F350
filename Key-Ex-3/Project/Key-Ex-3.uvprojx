# Keil uVision project Key-Ex-3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Key-Ex-3.elf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F3X0_XD,USE_STDPERIPH_DRIVER
  c include: ..\UserHeader;..\Libraries\CMSIS;..\Libraries\CMSIS\GD\GD32F3x0\Include;..\Libraries\GD32F3x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Libraries/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group CMSIS
    ../Libraries/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group GD32F3x0_Libraries
    ../Libraries/GD32F3x0_standard_peripheral/Source/: gd32f3x0_rcu.c gd32f3x0_gpio.c gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group UserSrc
    ../UserSrc/: main.c gd32f3x0_it.c systick.c LED.c Gpio.c Key.c EXTI_Gpio.c Pjt_SysTick.c gSysVar.c SysTimer.c Uart.c FIFO.c
  group UserHeader
    ../UserHeader/: main.h gd32f3x0_libopt.h gd32f3x0_it.h systick.h LED.h Gpio.h Key.h EXTI_Gpio.h Pjt_SysTick.h gSysVar.h SysTimer.h Uart.h FIFO.h
